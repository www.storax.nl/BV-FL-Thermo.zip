Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 4e0a394f-e3c0-424a-ab37-957d37cfedd5.ifc
Time: 2026-08-11T11:22:40
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik geïsoleerd enkel, uitneembaar Storax - BV-FL-THERMO 106, 600x1000mm
In: Bouwlaag
Material: staal
Pset_WindowCommon - Rc-waarde: 4 m²·k/w
Pset_Data - WUID: AgAAABXW8rYDAAAA4OwCAAV2SgAAJVQBAFJfAQDt6wIALusCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAABXW8rYDAAAA4OwCAAV2SgAAJVQBAFJfAQDt6wIALusCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); gewicht per st: 33 kg/st; STABU2: 43.31.10; lengte: 730 mm; dagmaatlengte: 600 mm; NAA.K.T: samengesteld_product_kozijn; breedte: 1130 mm; Rc-waarde: 4 m²·k/w; type: 106; serie: BV-FL-THERMO; afsluitbaar: True; hoogte: 50 mm; merk: Storax; breuklast: A15; dagmaatbreedte: 1000 mm; omranding: staal; luik: staal
