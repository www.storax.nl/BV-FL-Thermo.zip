Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 7d8bab33-2049-4d3c-ad08-56cbbf1d5dd9.ifc
Time: 2026-08-11T11:22:14
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik geïsoleerd enkel, uitneembaar Storax - BV-FL-THERMO 88, 800x800mm
In: Bouwlaag
Material: staal
Pset_WindowCommon - Rc-waarde: 4 m²·k/w
Pset_Data - WUID: AgAAABXd9bYDAAAA4OwCAAV2SgAAJVQBAFJfAQDt6wIAJewCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAABXd9bYDAAAA4OwCAAV2SgAAJVQBAFJfAQDt6wIAJewCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); gewicht per st: 33 kg/st; STABU2: 43.31.10; lengte: 930 mm; dagmaatlengte: 800 mm; NAA.K.T: samengesteld_product_kozijn; breedte: 930 mm; Rc-waarde: 4 m²·k/w; type: 88; serie: BV-FL-THERMO; afsluitbaar: True; hoogte: 50 mm; merk: Storax; breuklast: A15; dagmaatbreedte: 800 mm; omranding: staal; luik: staal
