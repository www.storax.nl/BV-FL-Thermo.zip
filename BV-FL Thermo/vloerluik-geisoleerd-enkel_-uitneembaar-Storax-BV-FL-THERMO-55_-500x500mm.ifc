Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 30855601-674d-40f7-8f94-e9b0bc3d8253.ifc
Time: 2026-08-11T11:20:42
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik geïsoleerd enkel, uitneembaar Storax - BV-FL-THERMO 55, 500x500mm
In: Bouwlaag
Material: staal
Pset_WindowCommon - Rc-waarde: 4 m²·k/w
Pset_Data - WUID: AgAAABXd8rYDAAAA4OwCAAV2SgAAJVQBAFJfAQDt6wIAJesCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAABXd8rYDAAAA4OwCAAV2SgAAJVQBAFJfAQDt6wIAJesCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); gewicht per st: 19 kg/st; STABU2: 43.31.10; lengte: 630 mm; dagmaatlengte: 500 mm; NAA.K.T: samengesteld_product_kozijn; breedte: 630 mm; Rc-waarde: 4 m²·k/w; type: 55; serie: BV-FL-THERMO; afsluitbaar: True; hoogte: 50 mm; merk: Storax; breuklast: A15; dagmaatbreedte: 500 mm; omranding: staal; luik: staal
