Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 38c87e6b-e572-45ed-839d-e2f7dc69f1b4.ifc
Time: 2026-08-11T11:21:10
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik geïsoleerd enkel, uitneembaar Storax - BV-FL-THERMO 66, 600x600mm
In: Bouwlaag
Material: staal
Pset_WindowCommon - Rc-waarde: 4 m²·k/w
Pset_Data - WUID: AgAAABVr8rYDAAAA4OwCAAV2SgAAJVQBAFJfAQDt6wIAk-sCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAABVr8rYDAAAA4OwCAAV2SgAAJVQBAFJfAQDt6wIAk-sCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); gewicht per st: 23 kg/st; STABU2: 43.31.10; lengte: 730 mm; dagmaatlengte: 600 mm; NAA.K.T: samengesteld_product_kozijn; breedte: 730 mm; Rc-waarde: 4 m²·k/w; type: 66; serie: BV-FL-THERMO; afsluitbaar: True; hoogte: 50 mm; merk: Storax; breuklast: A15; dagmaatbreedte: 600 mm; omranding: staal; luik: staal
